# IAR project example.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV58F1M0xxx24 NXP MKV58F1M0xxx24
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MKV58F1M0VLQ24; TWR_KV58F220M; TOWER
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\Libraries\drives\inc; ..\..\Libraries\startup\CMSIS; ..\..\Libraries\startup\startup; ..\USER\inc; ..\..\Libraries\board\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: example.srec
  ILINK.IlinkOutputFile: example.out
  ILINK.IlinkIcfFile: MKV58F1M0xxx24_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group board/board_c
    ../../Libraries/board/src/: mpu6050.c oscilloscope.c
  group board/board_h
    ../../Libraries/board/inc/: mpu6050.h oscilloscope.h
  group drives/drives_c
    ../../Libraries/drives/src/: kv58_adc.c kv58_clock.c kv58_ftm.c kv58_gpio.c kv58_i2c_soft.c kv58_led.c kv58_pit.c kv58_port.c kv58_systick.c kv58_uart.c
  group drives/drives_h
    ../../Libraries/drives/inc/: kv58_adc.h kv58_clock.h kv58_ftm.h kv58_gpio.h kv58_i2c_soft.h kv58_led.h kv58_pit.h kv58_port.h kv58_port_cfg.h kv58_systick.h kv58_uart.h
  group startup
    ../../Libraries/startup/startup/: startup_MKV58F24.s system_MKV58F24.c
  group user/user_c
    ../USER/src/: main.c
  group user/user_h
    ../USER/inc/: headfile.h
